#include "ha_entity_id.h"

#include <cstring>

namespace ha_entity_id {

bool normalize(const char *in, const char *domain, char *out, size_t cap) {
  if (in == nullptr || domain == nullptr || out == nullptr || cap < kMax) {
    return false;
  }
  const char *b = in;
  while (*b == ' ') {
    b++;
  }
  const char *e = b + strlen(b);
  while (e > b && e[-1] == ' ') {
    e--;
  }
  const size_t n = (size_t)(e - b);
  if (n == 0) {
    out[0] = '';
    return true;
  }
  const size_t dn = strlen(domain);
  if (n >= kMax || n <= dn + 1 || strncmp(b, domain, dn) != 0 || b[dn] != '.') {
    return false;
  }
  for (const char *c = b + dn + 1; c < e; c++) {
    const bool ok = (*c >= 'a' && *c <= 'z') || (*c >= '0' && *c <= '9') || *c == '_';
    if (!ok) {
      return false;
    }
  }
  memcpy(out, b, n);
  out[n] = '';
  return true;
}

} // namespace ha_entity_id
